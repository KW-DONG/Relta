# Keil uVision project Relta.uvprojx, settings and files
target RELTA (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Relta
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\library\atom\delay;..\library\atom\sys;..\library\std\inc;..\module;..\user\LDR_v0.2;..\core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group LIB
    ../library/atom/delay/: delay.c
    ../library/std/src/: stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../library/atom/sys/: sys.c
  group MODULE
    ../module/: bsp.c buffer.c delta.c gcode.c motion.c planner.c
  group USER
    ../user/LDR_v0.2/: main.c stm32f4xx_it.c system_stm32f4xx.c
