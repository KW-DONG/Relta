# Keil uVision project LDR.uvprojx, settings and files
target LDR (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LDR
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\core;..\driver\inc;..\library\std\inc;..\library\atom\delay;..\library\atom\sys;..\user\LDR;..\library\atom\usart
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../core/: startup_stm32f40_41xxx.s
  group driver
    ../driver/src/: Driver_BSP.c Driver_Gcode.c Driver_IRQHandler.c Driver_LED.c Driver_Motion.c Driver_Motor.c
  group library
    ../library/std/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
    ../library/atom/delay/: delay.c
    ../library/atom/sys/: sys.c
    ../library/atom/usart/: usart.c
  group user
    ../user/LDR/: main.c stm32f4xx_it.c system_stm32f4xx.c
